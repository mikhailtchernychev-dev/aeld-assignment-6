#inherit externalsrc
#EXTERNALSRC = "/data/coursera-linux/assignment-1-mikhailtchernychev-dev/aesd-char-driver"
#EXTERNALSRC_BUILD = "/data/coursera-linux/assignment-1-mikhailtchernychev-dev/aesd-char-driver"
