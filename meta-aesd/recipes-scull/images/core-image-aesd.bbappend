IMAGE_INSTALL:append = " scull"
