IMAGE_INSTALL:append = " nano"