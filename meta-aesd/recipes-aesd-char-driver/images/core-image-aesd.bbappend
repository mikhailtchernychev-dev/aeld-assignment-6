IMAGE_INSTALL:append = " aesd-char-driver"
