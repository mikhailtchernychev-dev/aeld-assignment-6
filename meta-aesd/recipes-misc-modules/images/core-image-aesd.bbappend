IMAGE_INSTALL:append = " misc-modules"
